# Keil uVision project Model.uvproj, settings and files
target Model (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Model +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: main.c
  group Driver
    ../Driver/: Key.c Key.h Seg.c Seg.h Init.c Init.h Led.c Led.h ds1302.c ds1302.h iic.c iic.h onewire.c onewire.h
