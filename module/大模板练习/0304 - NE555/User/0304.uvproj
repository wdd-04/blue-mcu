# Keil uVision project 0304.uvproj, settings and files
target 0304 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 0304 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: main.c
  group Driver
    ../Driver/: Init.c Init.h Key.c Key.h Led.c Led.h Seg.c Seg.h ds1302.c iic.c onewire.c ds1302.h iic.h onewire.h
